DESCRIPTION = "Helper app to populate the initial /dev directory with the required devices when they don't exist yet"

require sh4-apps.inc
