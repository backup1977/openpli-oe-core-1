OPTIONAL_PACKAGES_remove_sh4 += "\
	gdb \
	nodejs\
	rclone \
	zerotier \
	udpxy \
	"

OPTIONAL_WIFI_PACKAGES_remove_sh4 = "\
	kernel-module-8189es \
	kernel-module-8723a \
	kernel-module-8723bu\
	kernel-module-8814au \
	kernel-module-88x2bu \
	"
